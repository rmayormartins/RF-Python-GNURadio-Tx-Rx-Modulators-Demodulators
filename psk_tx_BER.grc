<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>out_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>0b00000000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10**(0.1*out_gain)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>M</value></param>
<param><key>samples_per_symbol</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>freq0</key><value>556e6</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate*50</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
